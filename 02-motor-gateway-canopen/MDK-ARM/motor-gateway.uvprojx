# Keil uVision project motor-gateway.uvprojx, settings and files
target motor-gateway (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: motor-gateway +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./Source/App;./Source/Com;./thirdpart/FreeRTOS/include;./Source/Int/CAN;./Source/Int/W5500;./Source/Int/MQTT;./Source/Int/MQTT/MQTTPacket/src;.\thirdpart\CANopenNode_STM32;.\thirdpart\CANopenNode;.\thirdpart\CANopenNode\301;.\thirdpart\CANopenNode\303;.\thirdpart\CANopenNode\304;.\thirdpart\CANopenNode\305;.\thirdpart\CANopenNode\309;.\thirdpart\CANopenNode\extra;.\thirdpart\CANopenNode\storage;.\thirdpart\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./Source/App/: App_Main.c App_Main.h
  group Com
    ./Source/Com/: cJSON.c cJSON.h
  group Int
    ./Source/Int/CAN/: Int_CAN.c Int_CAN.h Int_CAN_OPEN.c Int_CAN_OPEN.h
    ./Source/Int/W5500/: Int_W5500.c Int_W5500.h
    ./Source/Int/MQTT/: Int_MQTT.c Int_MQTT.h
  group thirdpart/FreeRTOS
    ./thirdpart/FreeRTOS/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./thirdpart/FreeRTOS/portable/: heap_4.c port.c
    ./thirdpart/FreeRTOS/include/: FreeRTOSConfig.h
  group thirdpart/W5500
    ./Source/Int/W5500/: dhcp.c dhcp.h dns.c dns.h httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h socket.c socket.h w5500.c w5500.h wizchip_conf.c wizchip_conf.h
  group thirdpart/MQTT
    ./Source/Int/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ./Source/Int/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group thirdpart/CanopenNode
    ./thirdpart/CANopenNode/: CANopen.c
    ./thirdpart/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
    ./thirdpart/CANopenNode/extra/: CO_trace.c
    ./thirdpart/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ./thirdpart/CANopenNode/303/: CO_LEDs.c
    ./thirdpart/CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ./thirdpart/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ./thirdpart/CANopenNode/309/: CO_gateway_ascii.c
  group thirdpart/CanopenNodeSTM32
    ./thirdpart/CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c OD.h CO_app_STM32.h CO_driver_target.h CO_storageBlank.h
software components: CMSIS:CORE 4.3.0
