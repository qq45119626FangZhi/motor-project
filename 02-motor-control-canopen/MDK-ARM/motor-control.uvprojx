# Keil uVision project motor-control.uvprojx, settings and files
target motor-control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: motor-control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./Source/App;./Source/Com;./Source/Int/MOTOR;./Source/Int/KEY;./Source/Int/ENCODER;./Source/Dri;./Source/Int/CAN;.\Thirdpart\CANopenNode_STM32;.\Thirdpart\CANopenNode;.\Thirdpart\CANopenNode\301;.\Thirdpart\CANopenNode\303;.\Thirdpart\CANopenNode\304;.\Thirdpart\CANopenNode\305;.\Thirdpart\CANopenNode\309;.\Thirdpart\CANopenNode\extra;.\Thirdpart\CANopenNode\storage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App
    ./Source/App/: App_Main.c App_Main.h
  group Int
    ./Source/Int/MOTOR/: Int_Motor.c Int_Motor.h
    ./Source/Int/KEY/: Int_Key.c Int_Key.h
    ./Source/Int/ENCODER/: Int_Encoder.c Int_Encoder.h
    ./Source/Int/CAN/: Int_CAN.c Int_CAN.h Int_CAN_OPEN.c Int_CAN_OPEN.h
  group Com
    ./Source/Com/: Com_Delay.c Com_Delay.h Com_DWT.c Com_DWT.h
  group Dri
    ./Source/Dri/: Dri_I2C.c Dri_I2C.h
  group Thirdpart/CanopenNode
    ./Thirdpart/CANopenNode/: CANopen.c
    ./Thirdpart/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ./Thirdpart/CANopenNode/303/: CO_LEDs.c
    ./Thirdpart/CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ./Thirdpart/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ./Thirdpart/CANopenNode/309/: CO_gateway_ascii.c
    ./Thirdpart/CANopenNode/extra/: CO_trace.c
    ./Thirdpart/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
  group Thirdpart/CanopeNodeSTM32
    ./Thirdpart/CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c OD.h CO_app_STM32.h CO_driver_target.h CO_storageBlank.h
software components: CMSIS:CORE 4.3.0
