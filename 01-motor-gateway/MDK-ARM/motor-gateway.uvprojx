# Keil uVision project motor-gateway.uvprojx, settings and files
target motor-gateway (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: motor-gateway +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./Source/App;./Source/Com;./thirdpart/FreeRTOS/include;./Source/Int/CAN;./Source/Int/W5500;./Source/Int/MQTT;./Source/Int/MQTT/MQTTPacket/src;./thirdpart/FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./Source/App/: App_Main.c App_Main.h
  group Com
    ./Source/Com/: cJSON.c cJSON.h
  group Int
    ./Source/Int/CAN/: Int_CAN.c Int_CAN.h
    ./Source/Int/W5500/: Int_W5500.c Int_W5500.h
    ./Source/Int/MQTT/: Int_MQTT.c Int_MQTT.h
  group thirdpart/FreeRTOS
    ./thirdpart/FreeRTOS/: event_groups.c croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./thirdpart/FreeRTOS/portable/: heap_4.c port.c
    ./thirdpart/FreeRTOS/include/: FreeRTOSConfig.h
  group thirdpart/W5500
    ./Source/Int/W5500/: dhcp.c dhcp.h dns.c dns.h httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h socket.c socket.h w5500.c w5500.h wizchip_conf.c wizchip_conf.h
  group thirdpart/MQTT
    ./Source/Int/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ./Source/Int/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
software components: CMSIS:CORE 4.3.0
